# Keil uVision project my_project_ROM.uvprojx, settings and files
target my_project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_project_rom
  AfterMake: fromelf --bin --output .\Build\my_project_ROM.bin .\Build\my_project_ROM.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_CM4
  c include: ..\..\hardware\inc;..\..\package\MultiTimer;..\..\sys\inc;..\..\msp432p4xx_lib;..\..\msp432p4xx_lib\CMSIS\Include;..\..\package\MultiButton
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../../: system_msp432p401r.c main.c
    ./: startup_msp432p401r_uvision.s
  group Library
    ../../msp432p4xx_lib/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
    ../../msp432p4xx_lib/CMSIS/DSP_Lib/lib/keil/m4f/: arm_cortexM4lf_math.a
    ../../../ti_driverlib/simplelink_msp432p4_sdk_3_40_01_02/ti/devices/msp432p4xx/driverlib/: adc14.c gpio.c uart.c cs.c pcm.c flash.c fpu.c
  group HARDWARE
    ../../hardware/: adc.c key.c key4x4.c led.c oled.c tim32.c timA.c
  group PACKAGE
    ../../package/MultiTimer/: MultiTimer.c
    ../../package/MultiButton/: multi_button.c
  group SYS
    ../../sys/: usart.c sysinit.c baudrate_calculate.c
software components: CMSIS:CORE 4.3.0
