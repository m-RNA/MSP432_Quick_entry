# Keil uVision project uart_pc_echo_12mhz_brclk.uvprojx, settings and files
target uart_pc_echo_12mhz_brclk (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_pc_echo_12mhz_brclk
  AfterMake: fromelf --bin --output .\Build\uart_pc_echo_12mhz_brclk.bin .\Build\uart_pc_echo_12mhz_brclk.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSP432P401R__
  c include: ../../../../../../source;../../../../../../source/third_party/CMSIS/Include/;..\..\RNA_UART_Int;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02\third_party\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: uart_pc_echo_12mhz_brclk.c system_msp432p401r.c baudrate_calculate.c sysinit.c
    ./: startup_msp432p401r_uvision.s
  group Library
    ../../ti_driverlib/simplelink_msp432p4_sdk_3_40_01_02/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
software components: CMSIS:CORE 5.5.0
